# Keil uVision project qtrack.uvproj, settings and files
target QTRACK_0 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 0 +hex
  AfterMake: fromelf.exe --bin -o  "$L@L.bin" "#L"
  c flags: Optim=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,_DEBUG,FACTORY,Q_SPY,PCB_V2_1
  c misc: --c99
  c include: .\main;.\bsp;.\config;.\CRC32;.\includes;.\CRC16;.\qport;.\CM3\CoreSupport;.\CM3\DeviceSupport;.\stm_lib\inc;.\navigation;.\Key;.\modem;.\QPC\port;.\QPC\inc;.\ModemRingBuf;.\SMS;.\ByteStream;.\memory;.\at45;.\FM25;.\FramRingBuf;.\Disk;.\CRC8;.\Control;.\Protocol;.\LedIndicator;.\Epsilon;.\my_time;.\RS485;.\IO;.\navigation_old;.\nav_filter;.\RF-10;.\TL10;.\CRC16-TELTONIKA;..\bootloader103\inc
  memory RVCT4: ROM 0x8002000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ./startup/: startup_stm32f10x_hd.s
  group Main
    ./main/: main.c
  group Bsp
    ./bsp/: bsp.c bsp.h
  group Config
    ./config/: config.c config.h config_sys.h stm32f10x_conf.h
  group CMSIS
    ./CM3/CoreSupport/: core_cm3.c
    ./CM3/DeviceSupport/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group inc
    ../bootloader/inc/: loader_defs.h
    ./includes/: user_types.h
  group CRC32
    ./CRC32/: crc32.h crc32.c
  group CRC16
    ./CRC16/: CRC16.c CRC16.h
  group qport
    ./QPC/port/: qep_port.h qf_port.h qk_port.h qk_port.s qs_port.h
  group StmLib
    ./stm_lib/src/: stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_exti.c
  group modem
    ./modem/: modem.c modem.h modem_parser.c modem_sim900.c
    ./ModemRingBuf/: ModemRingBuf.c
  group qf
    ./QPC/qf/: qa_ctor.c qa_defer.c qa_fifo.c qa_get_.c qa_lifo.c qa_sub.c qa_usub.c qa_usuba.c qeq_fifo.c qeq_get.c qeq_init.c qeq_lifo.c qf_act.c qf_gc.c qf_log2.c qf_new.c qf_pool.c qf_psini.c qf_pspub.c qf_pwr2.c qf_tick.c qma_ctor.c qmp_get.c qmp_init.c qmp_put.c qte_arm.c qte_ctor.c qte_ctr.c qte_darm.c qte_rarm.c
  group qk
    ./QPC/qk/: qk.c qk_ext.c qk_mutex.c qk_sched.c
  group qs
    ./QPC/qs/: qs.c qs_.c qs_blk.c qs_byte.c qs_dict.c qs_f32.c qs_f64.c qs_mem.c qs_str.c qs_u64.c
  group qep
    ./QPC/qep/: qep.c qep_pkg.h qfsm_dis.c qfsm_ini.c qhsm_dis.c qhsm_in.c qhsm_ini.c qhsm_top.c qmsm_dis.c qmsm_ini.c
  group SMS
    ./SMS/: ParserSms.c ParserSms.h
  group ByteStream
    ./ByteStream/: ByteStream.c ByteStream.h
  group memory
    ./memory/: memory_spi.c memory_spi.h
  group AT45
    ./at45/: at45db.c at45db.h
  group FM25
    ./FM25/: fm25cl64.c fm25cl64.h
  group FramRingBuf
    ./FramRingBuf/: FramRingBuf.c FramRingBuf.h
  group Disk
    ./Disk/: Disk.c Disk.h
  group IO
    ./RS485/: rs485.c rs485.h
    ./IO/: io.h io.c
  group CRC8
    ./CRC8/: crc8.c crc8.h
  group LedIndicator
    ./LedIndicator/: LedIndicator.c LedIndicator.h
  group Control
    ./Control/: Control_new.c Control.h
  group Epsilon
    ./Epsilon/: epsilon.c epsilon.h
  group my_time
    ./my_time/: my_time.c my_time.h
  group navigation
    ./navigation_old/: nmea_parser.c
    ./nav_filter/: nav_filter.c
    ./navigation/: gps_ring_buf.c
  group RF10
    ./RF-10/: rf10.c
  group TL10
    ./TL10/: tl10.c tl10.h
  group crc16_teltonika
    ./CRC16-TELTONIKA/: crc16_teltonika.c crc16_teltonika.h
target QTRACK_1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: as above
  output: 1 +hex
  AfterMake: fromelf.exe --bin -o  "$L@L.bin" "#L"
  c flags: Optim=2
  c define: USE_STDPERIPH_DRIVER, STM32F30X_HD,_DEBUG,Q_SPY,PCB_V2_1
  c misc: --c99
  c include: .\main;.\bsp;.\config;.\CRC32;.\includes;.\CRC16;.\qport;.\CM3\CoreSupport;.\CM3\DeviceSupport;.\stm_lib\inc;.\Key;.\modem;.\QPC\port;.\QPC\inc;.\ModemRingBuf;.\SMS;.\ByteStream;.\memory;.\at45;.\FM25;.\FramRingBuf;.\Disk;.\IO;.\MR9;.\CRC8;.\Control;.\Protocol;.\LedIndicator;.\Epsilon;..\bootloader\inc;.\my_time;.\navigation_old;.\RS485;.\nav_filter;.\RF-10;.\TL10;.\CRC16-TELTONIKA;.\navigation
  memory RVCT4: ROM 0x8021000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target TEST (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: 0 +hex
  AfterMake: fromelf.exe --bin -o  "$L@L.bin" "#L"
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,_DEBUG,FACTORY,Q_SPY,PCB_V1_1,TEST
  c misc: --c99
  c include: .\main;.\bsp;.\config;.\CRC32;.\includes;.\CRC16;.\qport;.\CM3\CoreSupport;.\CM3\DeviceSupport;.\stm_lib\inc;.\navigation;.\Key;.\modem;.\QPC\port;.\QPC\inc;.\ModemRingBuf;.\SMS;.\ByteStream;.\memory;.\at45;.\FM25;.\FramRingBuf;.\Disk;.\CRC8;.\Control;.\Protocol;.\LedIndicator;.\Epsilon;..\bootloader\inc;.\my_time;.\RS485;.\IO;.\navigation_old;.\nav_filter;.\RF-10;.\TL10
  memory RVCT4: ROM 0x8002000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
target OLEG (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: as above
  output: 0 +hex
  AfterMake: fromelf.exe --bin -o  "$L@L.bin" "#L"
  c flags: Optim=3
  c define: USE_STDPERIPH_DRIVER, STM32F30X_HD,_DEBUG,FACTORY,Q_SPY,PCB_V1_1,OLEG
  c misc: --c99
  c include: .\main;.\bsp;.\config;.\CRC32;.\includes;.\CRC16;.\qport;.\CM3\CoreSupport;.\CM3\DeviceSupport;.\stm_lib\inc;.\navigation;.\Key;.\modem;.\QPC\port;.\QPC\inc;.\ModemRingBuf;.\SMS;.\ByteStream;.\memory;.\at45;.\FM25;.\FramRingBuf;.\Disk;.\CRC8;.\Control;.\Protocol;.\LedIndicator;.\Epsilon;..\bootloader\inc;.\my_time;.\RS485;.\IO;.\navigation_old;.\nav_filter;.\RF-10;.\TL10;.\CRC16-TELTONIKA
  memory RVCT4: ROM 0x8002000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
