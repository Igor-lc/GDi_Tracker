# Keil uVision project bootloader.uvproj, settings and files
target BootLoader (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: boot +hex
  AfterMake: fromelf --bin --output .\Obj\bin\bootloader.bin .\Obj\bootloader.axf
  c flags: Optim=2
  c define: STM32F30X_HD,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\inc;.\lib\inc;.\bsp;.\main;.\CM3\CoreSupport;.\CM3\DeviceSupport
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ./startup/: startup_stm32f10x_hd.s
  group Lib
    ./lib/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c
  group bsp
    ./bsp/: bsp.h bsp.c
  group main
    ./main/: main.h main.c
  group CM
    ./CM3/CoreSupport/: core_cm3.c
    ./CM3/DeviceSupport/: system_stm32f10x.c
